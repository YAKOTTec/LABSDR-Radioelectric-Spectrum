<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>QT_bladeRF_Spectrum_Analyzer</value></param>
<param><key>author</key><value>YAKOTT</value></param>
<param><key>description</key><value>Analizador de Espectro Radioeléctrico en el rango de 300 MHz a 3800 MHz</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>QT_bladeRF_Spectrum_Analyzer</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ancho_Banda</value></param>
<param><key>comment</key><value>Bandwidth operation.</value></param>
<param><key>value</key><value>22e6</value></param>
<param><key>gui_hint</key><value>Parametros@0:(3,0,1,1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1.5e6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>28e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Frecuencia</value></param>
<param><key>comment</key><value>Frequency rage operation.</value></param>
<param><key>value</key><value>870e6</value></param>
<param><key>gui_hint</key><value>Parametros@0:(1,0,1,1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>300e6</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>3800e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Ganancia_RF</value></param>
<param><key>comment</key><value>Gain RF.</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>Parametros@0:(0,0,1,1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Spam</value></param>
<param><key>value</key><value>2.4e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100</value></param>
<param><key>step</key><value>1000</value></param>
<param><key>stop</key><value>3e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Spam</value></param>
<param><key>comment</key><value>Used to watch a signal with less bandwidth.
Ex: FM channel of 220 kHz.</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Tasa_Muestreo</value></param>
<param><key>comment</key><value>Ideal Sample Rate.</value></param>
<param><key>value</key><value>22e6</value></param>
<param><key>gui_hint</key><value>Parametros@0:(4,0,1,1)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>160e3</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>40e6</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Graficas</value></param>
<param><key>gui_hint</key><value>(2,0,1,1)</value></param>
<param><key>label0</key><value>FFT</value></param>
<param><key>label1</key><value>FFT Resampler</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Parametros</value></param>
<param><key>gui_hint</key><value>(0,0,1,1)</value></param>
<param><key>label0</key><value>Parámetros</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>Reduce CPU usage.</value></param>
<param><key>samples_per_second</key><value>Ancho_Banda</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>El ancho de banda del SDR es equivalente a la tasa de muestreo.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>El Spam, para visualizar una señal con menor ancho de banda.</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>Ancho_Banda</value></param>
<param><key>freq0</key><value>Frecuencia</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>Ganancia_RF</value></param>
<param><key>comment</key><value>Used to obtain data from SDR devices.</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>Tasa_Muestreo</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Ancho_Banda</value></param>
<param><key>fc</key><value>Frecuencia</value></param>
<param><key>comment</key><value>Plot FFT over frequency.</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>Graficas@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"FFT"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>30</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Spam</value></param>
<param><key>fc</key><value>Frecuencia</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>Graficas@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"FFT Resampler"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>30</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>Ancho_Banda</value></param>
<param><key>fc</key><value>Frecuencia</value></param>
<param><key>comment</key><value>Plot FFT over time.</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>(1,0,1,1)</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>30</value></param>
<param><key>name</key><value>"Waterfall"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>Decimation resampler to increase or decrease
sample rate.</value></param>
<param><key>decim</key><value>int(Ancho_Banda)</value></param>
<param><key>interp</key><value>int(Spam)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
